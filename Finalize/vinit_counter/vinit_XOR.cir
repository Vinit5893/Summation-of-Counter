* C:\FOSSEE\eSim\library\SubcircuitLibrary\vinit_XOR\vinit_XOR.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 11/13/22 16:22:33

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
SC3  Net-_SC13-Pad1_ Net-_SC1-Pad2_ Net-_SC3-Pad3_ Net-_SC3-Pad3_ sky130_fd_pr__nfet_01v8_lvt
SC1  Net-_SC1-Pad1_ Net-_SC1-Pad2_ Net-_SC1-Pad3_ Net-_SC1-Pad3_ sky130_fd_pr__pfet_01v8_lvt
SC5  Net-_SC5-Pad1_ Net-_SC10-Pad1_ Net-_SC1-Pad3_ Net-_SC1-Pad3_ sky130_fd_pr__pfet_01v8_lvt
SC7  Net-_SC13-Pad1_ Net-_SC10-Pad1_ Net-_SC7-Pad3_ Net-_SC7-Pad3_ sky130_fd_pr__nfet_01v8_lvt
SC4  Net-_SC3-Pad3_ Net-_SC11-Pad2_ Net-_SC10-Pad3_ Net-_SC10-Pad3_ sky130_fd_pr__nfet_01v8_lvt
SC8  Net-_SC7-Pad3_ Net-_SC11-Pad1_ Net-_SC10-Pad3_ Net-_SC10-Pad3_ sky130_fd_pr__nfet_01v8_lvt
SC2  Net-_SC13-Pad1_ Net-_SC11-Pad1_ Net-_SC1-Pad1_ Net-_SC1-Pad1_ sky130_fd_pr__pfet_01v8_lvt
SC6  Net-_SC13-Pad1_ Net-_SC11-Pad2_ Net-_SC5-Pad1_ Net-_SC5-Pad1_ sky130_fd_pr__pfet_01v8_lvt
SC12  Net-_SC11-Pad1_ Net-_SC11-Pad2_ Net-_SC10-Pad3_ Net-_SC10-Pad3_ sky130_fd_pr__nfet_01v8_lvt
SC11  Net-_SC11-Pad1_ Net-_SC11-Pad2_ Net-_SC1-Pad3_ Net-_SC1-Pad3_ sky130_fd_pr__pfet_01v8_lvt
SC10  Net-_SC10-Pad1_ Net-_SC1-Pad2_ Net-_SC10-Pad3_ Net-_SC10-Pad3_ sky130_fd_pr__nfet_01v8_lvt
SC9  Net-_SC10-Pad1_ Net-_SC1-Pad2_ Net-_SC1-Pad3_ Net-_SC1-Pad3_ sky130_fd_pr__pfet_01v8_lvt
SC13  Net-_SC13-Pad1_ Net-_SC13-Pad2_ Net-_SC13-Pad1_ sky130_fd_pr__res_generic_pd
SC14  Net-_SC13-Pad2_ Net-_SC10-Pad3_ sky130_fd_pr__cap_mim_m3_1
U1  Net-_SC10-Pad3_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_SC1-Pad3_ Net-_U1-Pad5_ PORT
U3  Net-_SC13-Pad2_ Net-_U1-Pad5_ adc_bridge_1
U2  Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_SC1-Pad2_ Net-_SC11-Pad2_ dac_bridge_2

.end
