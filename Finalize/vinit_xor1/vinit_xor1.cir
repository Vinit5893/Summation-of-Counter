* C:\Users\vinit\Desktop\SUMMATION-OF-COUNTER\vinit_xor1\vinit_xor1.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 11/12/22 16:07:40

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
SC3  Net-_SC13-Pad1_ a Net-_SC3-Pad3_ Net-_SC3-Pad3_ sky130_fd_pr__nfet_01v8_lvt
SC1  Net-_SC1-Pad1_ a Net-_SC1-Pad3_ Net-_SC1-Pad3_ sky130_fd_pr__pfet_01v8_lvt
SC5  Net-_SC5-Pad1_ Net-_SC10-Pad1_ Net-_SC1-Pad3_ Net-_SC1-Pad3_ sky130_fd_pr__pfet_01v8_lvt
SC7  Net-_SC13-Pad1_ Net-_SC10-Pad1_ Net-_SC7-Pad3_ Net-_SC7-Pad3_ sky130_fd_pr__nfet_01v8_lvt
SC4  Net-_SC3-Pad3_ b GND GND sky130_fd_pr__nfet_01v8_lvt
SC8  Net-_SC7-Pad3_ Net-_SC11-Pad1_ GND GND sky130_fd_pr__nfet_01v8_lvt
SC2  Net-_SC13-Pad1_ Net-_SC11-Pad1_ Net-_SC1-Pad1_ Net-_SC1-Pad1_ sky130_fd_pr__pfet_01v8_lvt
SC6  Net-_SC13-Pad1_ b Net-_SC5-Pad1_ Net-_SC5-Pad1_ sky130_fd_pr__pfet_01v8_lvt
v2  a GND pulse
v3  b GND pulse
v1  Net-_SC1-Pad3_ GND DC
scmode1  SKY130mode
U1  a plot_v1
U2  b plot_v1
SC12  Net-_SC11-Pad1_ b GND GND sky130_fd_pr__nfet_01v8_lvt
SC11  Net-_SC11-Pad1_ b Net-_SC1-Pad3_ Net-_SC1-Pad3_ sky130_fd_pr__pfet_01v8_lvt
SC10  Net-_SC10-Pad1_ a GND GND sky130_fd_pr__nfet_01v8_lvt
SC9  Net-_SC10-Pad1_ a Net-_SC1-Pad3_ Net-_SC1-Pad3_ sky130_fd_pr__pfet_01v8_lvt
U3  y plot_v1
SC13  Net-_SC13-Pad1_ y Net-_SC13-Pad1_ sky130_fd_pr__res_generic_pd
SC14  y GND sky130_fd_pr__cap_mim_m3_1

.end
